# Keil uVision project STM32.uvprojx, settings and files
target STM32F103 Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN
  c flags: Optim=4 uC99=1 uGnu=1
  c include: ..\stack\CMSIS-DRIVER;..\stack;..\example;..\..\CANopenNode-v1.3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Files
    ../example/: CO_OD.c application.c main.c
    ../stack/CMSIS-DRIVER/: eeprom.c CO_driver.c
  group Documentation
    ./: Abstract.txt
  group Stack
    ../stack/: CO_Emergency.c CO_HBconsumer.c CO_LSSmaster.c CO_LSSslave.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c CO_TIME.c CO_trace.c crc16-ccitt.c
    ../: CANopen.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, CMSIS Driver:CAN 1.9, Device:GPIO 1.3, Device:Startup 1.0.0
