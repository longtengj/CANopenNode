# Keil uVision project GD32.uvprojx, settings and files
target GD32F103 Flash (6150000::V6.15::ARMCLANG)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2226 +hex
  c flags: Optim=4 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: CO_VERSION_MAJOR=4,GD32F10X_MD
  c include: ..\301;..\303;..\304;..\305;..\309;..\..\CANopenNode-v1.3;.\app;..\extra;.\app\storage;..\storage
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Files
    ./app/: main.c OD.c CO_driver_GD32F10X.c
    ../storage/: CO_storage.c
    ./app/storage/: CO_storageFlash.c
  group Documentation
    ./: Abstract.txt
  group CANopenNode
    ../301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c CO_ODinterface.c
    ../303/: CO_LEDs.c
    ../304/: CO_GFC.c CO_SRDO.c
    ../305/: CO_LSSmaster.c CO_LSSslave.c
    ../309/: CO_gateway_ascii.c
    ../: CANopen.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:GD32F10x_StdPeripherals:CAN 2.0.1, Device:GD32F10x_StdPeripherals:DBG 2.0.1, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
